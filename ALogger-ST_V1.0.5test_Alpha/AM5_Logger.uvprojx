# Keil uVision project AM5_Logger.uvprojx, settings and files
target DEBUG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AM5_Logger +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RTT_LOG_ENABLED USE_FULL_ASSERT HSE_VALUE=16000000 STM32F405xx
  c misc: --diag_suppress=177
  c include: .\inc;.\driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group RTOS
    ./inc/: osObjects.h
    ./src/: main.c thread_term.c thread_button.c thread_fs.c thread_gui.c
  group HAL
    ./src/: stm32f4xx_it.c USBD_User_Device_0.c USBD_User_MSC_0.c RTC.c OLED.c SPI.c I2C.c
    ./inc/: stm32f4xx_it.h RTC.h OLED.h SPI.h I2C.h
  group Sensor
    ./driver/: driver_acc.h driver_acc.c driver_gyo.h driver_gyo.c driver_mag.h driver_mag.c driver_hrv.h driver_hrv.c
    ./inc/: BMI160_reg.h BMI160.h ADXL362_reg.h ADXL362.h LIS3MDL_reg.h LIS3MDL.h BMM150_reg.h BMM150.h ADPD174.h
    ./src/: BMI160.c ADXL362.c LIS3MDL.c BMM150.c ADPD174.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Compiler:Event Recorder 1.1.0, Compiler:I/O:File 1.2.0, File System:CORE 6.9.4, File System:Drive:Memory Card 6.9.4, USB:CORE 6.10.0, USB:Device 6.10.0, USB:Device:MSC 6.10.0, CMSIS Driver:I2C 2.6, CMSIS Driver:MCI 2.7, CMSIS Driver:SPI 2.9, CMSIS Driver:USB Device:High-speed 2.16, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:RTC 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:Startup 2.6.0, J-Link:RTT Logger 5.10t, Graphics:CORE 5.36.6, Graphics:Display:Interface Template 5.36.6
